# Keil uVision project Software.uvprojx, settings and files
target Software (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Software
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC
  c misc: --C99
  c include: ../Inc;                          ../Drivers/STM32F4xx_HAL_Driver/Inc;                          ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                          ../Middlewares/Third_Party/FatFs/src/drivers;                          ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                          ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                          ../Middlewares/Third_Party/FatFs/src;                          ../Middlewares/Third_Party/FreeRTOS/Source/include;                          ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                          ../Drivers/CMSIS/Include;                          ..\Appl\stm32_topway_16x2\includes
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c tasks.c list.c queue.c timers.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_sd.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c freertos.c fatfs.c bsp_driver_sd.c stm32f4xx_hal_timebase_TIM.c
    ../Appl/stm32_topway_16x2/src/: stm32_topway_16x2.c
    ./: RTC_user_Init.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
software components: CMSIS:CORE 4.1.0
